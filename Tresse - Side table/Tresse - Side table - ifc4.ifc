Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Tresse - Side table - ifc4.ifc
Time: 2023-10-09T17:16:00
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (3)
Name
 | 1_1 - ObjectType: SketchupGroup
 | 1_2 - ObjectType: SketchupGroup
 | 1_0 - ObjectType: SketchupGroup
